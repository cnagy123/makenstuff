# IAR project current_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.PreInclude: config\includes.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; src; src\inc; src\tmp; ..\..\third_party\ti; ..\..\third_party
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; src; src\inc; src\tmp; ..\..\third_party\ti
  OBJCOPY.OOCOutputFile: current_project.bin
  ILINK.IlinkOutputFile: project_01.out
  ILINK.IlinkIcfFile: config\current_project.icf
  ILINK.IlinkAdditionalLibs: ..\..\third_party\ti\driverlib\ewarm\Exe\driverlib.a; ..\..\third_party\ti\grlib\ewarm\Exe\grlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    src/: application.c init.c main.c startup.c
  group Application/inc
    src/inc/: application.h init.h
  group Application/sys
    src/inc/: colors.h defines.h globals.h
    src/: globals.c
  group Config
    config/: config.h includes.h project_01.icf
  group Libraries
    ../../third_party/ti/driverlib/ewarm/Exe/: driverlib.a
    ../../third_party/ti/grlib/ewarm/Exe/: grlib.a
  group Peripherals/LCD_ILI9341
    src/inc/: ili9341.h lcd.h
    src/: lcd.c
  group Peripherals/Memory/AT24
    src/: at24.c
    src/inc/: at24.h
  group Peripherals/Memory/SD
    src/: sd.c
    src/inc/: sd.h
  group Peripherals/On Board
    src/: onBoard.c
    src/inc/: onBoard.h
  group Peripherals/Timers
    src/: systick.c timer0.c timer1.c
    src/inc/: systick.h timer0.h timer1.h
  group Protocols/I2C
    src/: i2c.c
    src/inc/: i2c.h
  group Protocols/SPI
    src/: spi.c
    src/inc/: spi.h
  group Protocols/uDMA
    src/: uDMA.c
    src/inc/: uDMA.h
