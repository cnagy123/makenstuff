<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\current_project\current_project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\third_party\ti\driverlib\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\third_party\ti\grlib\grlib.ewp</path>
  </project>
  <batchBuild/>
</workspace>


